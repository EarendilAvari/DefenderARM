# Keil uVision project DefenderARM.uvproj, settings and files
target DefenderARM (ARM-ADS)
  device: LM4F120H5QR Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: DefenderARM
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./Main/: MainThread.c sprite.c TExaS.c random.h random.s StartImage.h startup.s TExaS.h
  group Controls
    ./Controls/: ADC.c ADC.h SlidePot.c SlidePot.h Switches.c Switches.h
  group Display
    ./Display/: ImageArrays.h Nokia5110.c Nokia5110.h
    ./display/: LED.c LED.h
  group Sounds
    ./Sounds/: DAC.c DAC.h Sound.c Sound.h SoundArrays.h
  group GameEngine
    ./GameEngine/: GameEngineCycle.c GameEngineCycle.h
    ./gameEngine/: Pixel.h Enemy.c Enemy.h Terrain.c Terrain.h PlayerShip.c PlayerShip.h
